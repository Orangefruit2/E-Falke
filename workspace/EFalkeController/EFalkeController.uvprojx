# Keil uVision project EFalkeController.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EFalkeController
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Display
    ./Display/: Display.c Led_Bar.c tm_stm32_delay.c Delay.h Display.h Led_Bar.h tm_stm32_delay.h
  group Serial
    ./Serial/: pi300_bms_msg.h pi300_control_msg.h pi300_polling_msg.h Serial.c Serial.h UART.c UART.h
  group CAN
    ./CAN/: can.c
  group MAIN
    ./: main.c main.h clock.c clock.h
software components: CMSIS:CORE 5.0.1, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:CAN 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:WWDG 1.6.0, Device:Startup 2.6.0
