# Keil uVision project CAN.uvproj, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000 VECT_TAB_SRAM __NO_SYSTICK __TEST
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Source Files
    ./: CAN.c CanDemo.c LED.c Retarget.c Serial.c
  group Documentation
    ./: Abstract.txt
target STM32F407 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: CAN
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000 __NO_SYSTICK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
